## config/boards/shields/sojusnano/Kconfig.shield
```kconfig
config SHIELD_SOJUSNANO
    def_bool $(shields_list_contains,sojusnano)
CONFIG_ZMK_SLEEP=y
CONFIG_ZMK_IDLE_SLEEP_TIMEOUT=180000
```
